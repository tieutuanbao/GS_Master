# Keil uVision project GS_master.uvprojx, settings and files
target GameShow Master (6190000::V6.19::ARMCLANG)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4 OneElfS=1 v6Lang=6 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103V_EVAL,USE_USB_FS,_WIZCHIP_=5500
  c include: ..\source;..\GD32E10x_Firmware_Library\GD32E10x_standard_peripheral\Include;..\GD32E10x_Firmware_Library\CMSIS\GD\GD32E10x\Include;..\GD32E10x_Firmware_Library\CMSIS;..\libs;..\RTT\RTT;..\RTT\Config;..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\device\core\Include;..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\driver\Include;..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\common;..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\class\hid;..\libs\hid;..\components\Ethernet;..\components\Ethernet\W5500;..\components\Internet\DHCP;..\components\W25Qxxx
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../source/: gd32e10x_it.c hid_keyboard_itf.c main.c custom_hid_core.c
  group cmsis
    ../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x Driver
    ../GD32E10x_Firmware_Library/GD32E10x_standard_peripheral/Source/: gd32e10x_dma.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_exti.c gd32e10x_pmu.c
  group startup
    ../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group usb
    ../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group Ethernet
    ../components/Ethernet/: wizchip_conf.c socket.c
    ../components/Ethernet/W5500/: w5500.c
  group libs
    ../libs/: delay.c delay.h millis.c millis.h
  group W25Q
    ../components/W25Qxxx/: W25Q.c
  group Internet
    ../components/Internet/DHCP/: dhcp.c
  group RTT
    ../RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../RTT/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
